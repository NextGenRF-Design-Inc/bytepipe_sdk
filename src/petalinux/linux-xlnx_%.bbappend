SRC_URI_append = " file://0001-usb-dwc3-xilinx-Deselect-the-PIPE-clock-for-USB2.0-o.patch"
  
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
